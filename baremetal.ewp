# IAR project baremetal.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: R7F702300B RH850 - R7F702300B
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCDefines: MEM_NON_UNIFIED=1
  ICCRH850.CCDiagSuppress: Pa089
  ICCRH850.CCIncludePath2: src\arch\rh850\inc; src\core\inc; src\drivers\rh850-u2a16_ostm\inc; src\platform\rh850-u2a16\inc; src\drivers\renesas_rlin3\inc; $TOOLKIT_DIR$\inc\c
  IASMRH850.AsmIncludePath: src\arch\rh850\inc; src\core\inc; src\drivers\rh850-u2a16_ostm\inc; src\platform\rh850-u2a16\inc; $TOOLKIT_DIR$\inc\c
  OBJCOPY.OOCOutputFile: baremetal.srec
  ILINK.IlinkOutputFile: baremetal.out
  ILINK.IlinkIcfFile: D:\Application\RH850_PROJECTS\iar_adapt\baremetal\others\link\lnkr7f702300b.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RH850)
  as the first configuration, except:
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group others/link
    others/link/: lnkr7f702300b.icf
  group src
    src/: main.c
  group src/arch/rh850
    src/arch/rh850/: exceptions.S init.c intc.c irq.c start.S
  group src/core
    src/core/: irq.c retarget.c virtio_console.c
  group src/drivers/renesas_rlin3
    src/drivers/renesas_rlin3/: renesas_rlin3.c
  group src/drivers/rh850-u2a16_ostm
    src/drivers/rh850-u2a16_ostm/: rh850-u2a16_ostm.c
  group src/platform/rh850-u2a16
    src/platform/rh850-u2a16/: u2a16.c
